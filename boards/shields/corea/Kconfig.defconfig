## boards/shields/corea/Kconfig.defconfig
```kconfig
if SHIELD_COREA

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "corea"

endif
```
